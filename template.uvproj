# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\模块.\User;.\Public;.\GUI;.\APP\tftlcd;.\APP\touch;.\模块
  link misc: REMOVEUNUSED
  group User
    ./: main.c
    ./模块/: bsp_time.c bsp_key.c
  group Public
    ./Public/: public.c uart.c
  group APP
    ./APP/tftlcd/: tftlcd.c
    ./APP/touch/: touch.c
  group GUI
    ./GUI/: gui.c Progress.c ui.c
